Commit message: Finished!

File: omni_description/urdf/omni.urdf (robot description, URDF)
Before this commit: robot phantom_omni, 7 links, 6 joints
Links:
- added link end_effector
Joints:
- added joint effector_transform: type fixed, parent tip, child end_effector, origin xyz=0 0.031 0 rpy=0 0 0
